# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\Inc;..\..\..\drivers\boards\STM32F429IGTX_FIRE\dwt;..\..\..\drivers\boards\STM32F429IGTX_FIRE\key;..\..\..\drivers\boards\STM32F429IGTX_FIRE\led;..\..\..\drivers\boards\STM32F429IGTX_FIRE\usart;..\..\..\drivers\bsp\stm32\STM32F4xx_StdPeriph_Driver\inc;..\..\..\arch\arm\cortex-m4;..\..\..\kernel\compat\cmsis;..\..\..\kernel\compat\cmsis\1.0;..\..\..\kernel\compat\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\OS_CONFIG;..\USER;..\USER\lwip-1.4.1\port\arch;..\USER\lwip-1.4.1\port\Standalone;..\USER\lwip-1.4.1\src\include\ipv4;..\USER\lwip-1.4.1\src\include\lwip;..\USER\lwip-1.4.1\src\include\netif;..\USER\lwip-1.4.1\src\include;..\USER\lwip-1.4.1\port;..\USER\App;..\USER\Bsp\LAN8742A;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429IGTX-LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: stm32f4xx_it.c system_stm32f4xx.c
    ../USER/: main.c
  group drivers
    ../../../drivers/boards/STM32F429IGTX_FIRE/dwt/: dwt.c
    ../../../drivers/boards/STM32F429IGTX_FIRE/key/: bsp_key.c
    ../../../drivers/boards/STM32F429IGTX_FIRE/led/: bsp_led.c
    ../../../drivers/boards/STM32F429IGTX_FIRE/usart/: bsp_debug_usart.c
    ../USER/Bsp/systick/: bsp_SysTick.c
    ../USER/Bsp/LAN8742A/: stm32f429_eth.c
  group stm32f4xx_std_periph
    ../../../drivers/bsp/stm32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group liteos/cmsis
    ../../../kernel/compat/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
  group liteos/arch
    ../../../kernel/: los_init.c
    ../../../arch/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group liteos/lwip
    ../USER/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../USER/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../USER/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../USER/lwip-1.4.1/src/netif/: etharp.c
    ../USER/lwip-1.4.1/port/Standalone/: ethernetif.c
  group MQTT
    ./: mqtt.c mqtt._buffer.c mqtt_loop.c
  group cJSON
    ./: cJSON.c
  group TCP/APP
    ./: wdt.c utils.c
    ../USER/App/: netconf.c tcp_echoclient.c
  group MALLOC
    ./: malloc.c
  group DHT11
    ./: bsp_dht11.c
  group DS18B20
    ./: ds18b20.c
  group LAN8742A
    ../USER/Bsp/LAN8742A/: LAN8742A.c
software components: CMSIS:CORE 5.0.1

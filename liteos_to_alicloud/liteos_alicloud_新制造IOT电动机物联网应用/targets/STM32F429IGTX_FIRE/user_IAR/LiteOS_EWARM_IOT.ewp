# IAR project LiteOS_EWARM_IOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F429_439xx; LWIP_DEBUG; MQTT_DIRECT; IOTX_WITHOUT_TLS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\m4\Inc; ..\..\..\drivers\bsp\stm32F4xx\inc; ..\..\..\arch; ..\..\..\drivers\boards\usart; ..\..\..\drivers\boards\dwt; ..\..\..\drivers\boards\key; ..\..\..\drivers\boards\LAN8742A; ..\..\..\drivers\boards\led; ..\..\..\kernel\include; ..\..\..\kernel\base\include; ..\..\..\config; ..\..\..\drivers\boards\lwip-1.4.1\src\include; ..\..\..\drivers\boards\lwip-1.4.1; ..\..\..\drivers\boards\lwip-1.4.1\port; ..\..\..\drivers\boards\lwip-1.4.1\src\include\ipv4; ..\..\..\drivers\boards\lwip-1.4.1\lwipopts; ..\..\..\drivers\boards\lwip-1.4.1\port\OS; ..\..\..\drivers\boards\lwip-1.4.1\mqtt; ..\..\..\framework\guider; ..\..\..\framework\system; ..\..\..\framework\LITE-log; ..\..\..\framework\LITE-utils; ..\..\..\framework\utils\digest; ..\..\..\framework\utils\misc; ..\..\..\framework\security; ..\..\..\framework\sdk-impl; ..\..\..\framework\mqtt; ..\..\..\framework\mqtt\MQTTPacket
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: LiteOS_EWARM_IOT.bin
  ILINK.IlinkOutputFile: LiteOS_EWARM_IOT.out
  ILINK.IlinkIcfFile: ..\m4\STM32F429I-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group LiteOS_EWARM_IOT/arch
    ../../../arch/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS_EWARM_IOT/config
    ../../../config/: los_builddef.h los_config.h los_printf.h
  group LiteOS_EWARM_IOT/cpu_m4
    ../m4/: HAL_OS.c HAL_TCP.c los_startup_iar.s stm32f4xx_it.c system_stm32f4xx.c
  group LiteOS_EWARM_IOT/drivers/boards
    ../../../drivers/boards/usart/: bsp_debug_usart.c
    ../../../drivers/boards/key/: bsp_key.c
    ../../../drivers/boards/led/: bsp_led.c
    ../../../drivers/boards/dwt/: dwt.c
    ../../../drivers/boards/LAN8742A/: LAN8742A.c stm32f429_eth.c
  group LiteOS_EWARM_IOT/drivers/bsp
    ../../../drivers/bsp/stm32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LiteOS_EWARM_IOT/drivers/lwip
    ../../../drivers/boards/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../drivers/boards/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../drivers/boards/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../drivers/boards/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../drivers/boards/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../../../drivers/boards/lwip-1.4.1/port/OS/: ethernetif.c sys_arch.c
    ../../../drivers/boards/lwip-1.4.1/lwipopts/: netconf.c
  group LiteOS_EWARM_IOT/framework
    ../../../framework/system/: ca.c device.c
    ../../../framework/guider/: guider.c
    ../../../framework/LITE-utils/: json_parser.c json_token.c mem_stats.c string_utils.c
    ../../../framework/mqtt/: mqtt-example.c mqtt_client.c
    ../../../framework/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../../../framework/sdk-impl/: sdk-impl.c
    ../../../framework/security/: security.c
    ../../../framework/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../../../framework/utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group LiteOS_EWARM_IOT/kernel
    ../../../kernel/: los_init.c
  group LiteOS_EWARM_IOT/kernel/base
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group LiteOS_EWARM_IOT/kernel/base/mem
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c
  group LiteOS_EWARM_IOT/user
    ./: main.c modbus.c

# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM, LOS_KERNEL_DEBUG_OUT
  c misc: --diag_suppress=66,1296,186
  c include: ..\Inc;..\..\..\kernel\compat\cmsis;..\..\..\kernel\compat\cmsis\1.0;..\..\..\kernel\compat\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\OS_CONFIG;..\..\..\arch\arm\cortex-m0;..\..\..\examples\include;..\..\..\drivers\boards\FRDM-KW41Z;..\..\..\drivers\bsp\nxp\MKW41Z512xxx4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: .\MKW41Z512xxx4_LiteOS.scf
  group startup
    ./: startup_MKW41Z4.s
  group user
    ../Src/: main.c system_MKW41Z4.c board.c clock_config.c fsl_debug_console.c pin_mux.c
  group drivers/boards
    ../../../drivers/boards/FRDM-KW41Z/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group liteos/cmsis
    ../../../kernel/compat/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
  group liteos/arch
    ../../../arch/arm/cortex-m0/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group drivers/bsp
    ../../../drivers/bsp/nxp/MKW41Z512xxx4/: fsl_lptmr.c fsl_lpuart.c fsl_sim.c fsl_clock.c fsl_gpio.c fsl_smc.c fsl_flash.c fsl_common.c
software components: CMSIS:CORE 5.0.1

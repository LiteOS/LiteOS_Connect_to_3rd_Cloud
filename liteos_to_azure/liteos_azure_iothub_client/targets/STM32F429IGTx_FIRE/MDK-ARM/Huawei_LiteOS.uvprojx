# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,WITH_LWIP,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_DTLS,WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\..\..\examples\include;..\..\..\test\include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\net\lwip_port;..\..\..\components\net\lwip_port\OS;..\bsp;..\..\..\components\azure-iot\iothub_client\inc;..\..\..\components\azure-iot\c-utility\inc;..\..\..\components\azure-iot\umqtt\inc;..\..\..\components\azure-iot\c-utility\pal\generic;..\..\..\components\azure-iot\c-utility\pal\inc;..\..\..\components\azure-iot\parson;..\..\..\components\wolfssl;..\..\..\components\wolfssl\wolfssl;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\azure-iot\certs
  asm misc: --diag_suppress=A1581W
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429IGTx-LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: main.c system_stm32f4xx.c usart.c dwt.c sys_init.c stm32f4xx_hal_rtc_msp.c stm32f4xx_hal_sdram_msp.c
    ../../../components/azure-iot/iothub_client/samples/iothub_client_sample_mqtt/: iothub_client_sample_mqtt.c
    ../../../components/net/lwip-2.0.3/src/apps/sntp/: sntp.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Drivers/bsp
    ../bsp/: bsp_sdram.c bsp_rtc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_eth.c stm32f4xx_hal_rng.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group lwip
    ../../../components/net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.0.3/src/core/ipv4/: ip4_frag.c ip4_addr.c ip4.c igmp.c icmp.c etharp.c dhcp.c autoip.c
    ../../../components/net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip_port/OS/: ethernetif.c sys_arch.c
  group azure/certs
    ../../../components/azure-iot/certs/: certs.c
  group azure/umqtt
    ../../../components/azure-iot/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group azure/iothub_client
    ../../../components/azure-iot/iothub_client/src/: blob.c iothub_client_authorization.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_client_retry_control.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c
  group azure/c-utility
    ../../../components/azure-iot/c-utility/src/: map.c base64.c buffer.c consolelogger.c constbuffer.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c optionhandler.c sastoken.c sha1.c sha224.c sha384-512.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c xlogging.c singlylinkedlist.c
  group azure/adapters
    ../../../components/azure-iot/c-utility/adapters/: agenttime_liteos.c httpapi_compact.c platform_liteos.c threadapi_liteos.c tickcounter_liteos.c tlsio_ssl_liteos.c
  group azure/parson
    ../../../components/azure-iot/parson/: parson.c
  group wolfssl
    ../../../components/wolfssl/src/: crl.c internal.c keys.c ocsp.c sniffer.c ssl.c tls.c tls13.c wolfio.c
    ../../../components/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c evp.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c pkcs12.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha3.c sha256.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_c32.c sp_c64.c sp_int.c sp_x86_64.c srp.c tfm.c wc_encrypt.c wc_port.c wolfevent.c wolfmath.c
    ../../../components/wolfssl/wolfcrypt/src/port/st/: stm32.c
software components: CMSIS:CORE 5.0.1

# IAR project HuaweiLiteOS_stm32f429.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429_439xx; USE_STDPERIPH_DRIVER; xUSE_DHCP
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m4; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\STM32F429I_WildFire; ..\..\platform\STM32F429I_WildFire\device; ..\..\platform\STM32F429I_WildFire\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\platform\STM32F429I_WildFire\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\platform\STM32F429I_WildFire\lwip-port; ..\..\platform\STM32F429I_WildFire\lwip-port\netif; ..\..\platform\STM32F429I_WildFire\lwip-port\arch; ..\..\components\lwip-2.0.2\include; ..\..\components\lwip-2.0.2\include\arch; ..\..\components\lwip-2.0.2\apps\httpserver; ..\..\components\lwip-2.0.2\apps\shell; ..\..\components\lwip-2.0.2\include\lwip\apps; ..\..\platform\STM32F429I_WildFire\app; ..\..\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_stm32f429.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS_stm32f429.out
  ILINK.IlinkIcfFile: ..\..\platform\STM32F429I_WildFire\STM32F429I-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/library
    ../../platform/STM32F429I_WildFire/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../platform/STM32F429I_WildFire/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
    ../../platform/STM32F429I_WildFire/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Huawei_LiteOS/lwip
    ../../components/lwip-2.0.2/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/lwip-2.0.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/lwip-2.0.2/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/lwip-2.0.2/netif/: ethernet.c
    ../../platform/STM32F429I_WildFire/lwip-port/netif/: ethernetif.c
    ../../components/lwip-2.0.2/arch/: sys_arch.c
  group Huawei_LiteOS/platform/stm32f429i
    ../../platform/STM32F429I_WildFire/: los_bsp_adapter.c los_bsp_flash.c los_bsp_key.c los_bsp_led.c los_bsp_lwip.c los_bsp_uart.c
  group Huawei_LiteOS/platform/stm32f429i/app
    ../../components/lwip-2.0.2/apps/httpserver/: httpserver-netconn.c
    ../../components/lwip-2.0.2/apps/mqtt/: mqtt.c
    ../../platform/STM32F429I_WildFire/app/: mqtt_client.c
    ../../components/lwip-2.0.2/apps/shell/: shell.c
  group Huawei_LiteOS/platform/stm32f429i/device
    ../../platform/STM32F429I_WildFire/device/: LAN8742A.c stm32f429_eth.c
  group Huawei_LiteOS/startup
    ../../platform/STM32F429I_WildFire/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c usr_cfg.h
